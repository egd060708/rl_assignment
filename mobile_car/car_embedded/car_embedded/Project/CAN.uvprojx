# Keil uVision project CAN.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\LCD;..\USER\LED;..\USER\usart1;..\USER\KEY;..\USER\CAN;..\USER\usart1;..\USER\TIMER;..\USER\BEEP;..\USER\INTERFACE;..\USER\usart1;..\Controller;..\USER\usart4;..\Controller\VehicleControl_ert_rtw;..\USER\ps2;..\USER\sys;..\USER\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c
  group Common
    ../Common/: common.c
  group USER
    ../USER/LED/: led.c
    ../USER/CAN/: can1.c can2.c
    ../USER/TIMER/: timer.c
    ../USER/BEEP/: beep.c
    ../USER/INTERFACE/: interface.c
    ../USER/ps2/: pstwo.c
    ../USER/usart1/: usart1.c
  group Controller
    ../Controller/VehicleControl_ert_rtw/: VehicleControl.c
software components: CMSIS:CORE 4.3.0
